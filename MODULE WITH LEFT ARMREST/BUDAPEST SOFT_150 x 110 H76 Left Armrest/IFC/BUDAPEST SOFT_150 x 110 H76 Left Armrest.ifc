Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: 6f53c040-94ea-41ba-959a-a05861d9735e, VersionGUID: c2de981a-dfe1-4e8b-ac5e-7470a00fcd02, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Coordinate condivise]
File name: BUDAPEST SOFT_150 x 110 H76 Left Armrest.ifc
Time: 2026-02-17T16:41:30+01:00
Written by: ODA SDAI 25.12
Made in: Autodesk - Revit 26.4.0.32 (ITA) - 26.4.0.32

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 999999; RefLongitude: 12, 35, 59, 999999; RefElevation: 0 m

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 2

# IfcBuildingStorey (2)
Name | LongName | Elevation (m)
0 - Piano Terra | 0 - Piano Terra | 0
1 - Piano Primo | 1 - Piano Primo | 3.1

# IfcFurnishingElement: BUDAPEST SOFT_150 x 110 H76 Left Armrest:BUDAPEST SOFT_150 x 110 H76 Left Armrest, BUDAPEST SOFT_150 x 110 H76 Left Armrest:BUDAPEST SOFT_150 x 110 H76 Left Armrest:154439
In: 0 - Piano Terra
Type - Material: Kashmir Chantilly, <Unnamed>, Brushed Unfinished Metal
Type - Pset_ManufacturerTypeInformation - Manufacturer: Baxter S.r.l.
Pset_QuantityTakeOff - Reference: BUDAPEST SOFT_150 x 110 H76 Left Armrest
