Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: df43cf1b-5658-4161-a85c-97fb6715d1e6, VersionGUID: 3e751776-d4a0-4200-b0e4-fc9f15d635e8, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Coordinate condivise]
File name: BUDAPEST SOFT_150 x 150 H76 CORNER MODULE.ifc
Time: 2026-02-27T20:56:43+01:00
Written by: ODA SDAI 25.12
Made in: Autodesk - Revit 26.4.0.32 (ITA) - 26.4.0.32

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 999999; RefLongitude: 12, 35, 59, 999999; RefElevation: 0 m

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 2

# IfcBuildingStorey (2)
Name | LongName | Elevation (m)
0 - Piano Terra | 0 - Piano Terra | 0
1 - Piano Primo | 1 - Piano Primo | 3.1

# IfcFurnishingElement: BUDAPEST SOFT_150 x 150 H76 CORNER MODULE:BUDAPEST SOFT_150 x 150 H76 CORNER MODULE, BUDAPEST SOFT_150 x 150 H76 CORNER MODULE:BUDAPEST SOFT_150 x 150 H76 CORNER MODULE:147720
In: 0 - Piano Terra
Type - Material: Kashmir Chantilly, <Unnamed>, Brushed Unfinished Metal
Type - Pset_ManufacturerTypeInformation - Manufacturer: Baxter S.r.l.
Pset_QuantityTakeOff - Reference: BUDAPEST SOFT_150 x 150 H76 CORNER MODULE
