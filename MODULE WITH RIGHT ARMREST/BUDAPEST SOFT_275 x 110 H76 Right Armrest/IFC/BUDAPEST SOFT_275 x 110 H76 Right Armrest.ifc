Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: fc00e615-58e1-45b1-8ef0-d122605d2911, VersionGUID: bf738aa0-d6c7-4129-973f-3dbf1f08add1, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Coordinate condivise]
File name: BUDAPEST SOFT_275 x 110 H76 Right Armrest.ifc
Time: 2026-02-23T09:52:52+01:00
Written by: ODA SDAI 25.12
Made in: Autodesk - Revit 26.4.0.32 (ITA) - 26.4.0.32

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 999999; RefLongitude: 12, 35, 59, 999999; RefElevation: 0 m

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 2

# IfcBuildingStorey (2)
Name | LongName | Elevation (m)
0 - Piano Terra | 0 - Piano Terra | 0
1 - Piano Primo | 1 - Piano Primo | 3.1

# IfcFurnishingElement: BUDAPEST SOFT_275 x 110 H76 Right Armrest:BUDAPEST SOFT_275 x 110 H76 Right Armrest, BUDAPEST SOFT_275 x 110 H76 Right Armrest:BUDAPEST SOFT_275 x 110 H76 Right Armrest:183863
In: 0 - Piano Terra
Type - Material: Kashmir Chantilly, <Unnamed>, Brushed Unfinished Metal
Type - Pset_ManufacturerTypeInformation - Manufacturer: Baxter S.r.l.
Pset_QuantityTakeOff - Reference: BUDAPEST SOFT_275 x 110 H76 Right Armrest
