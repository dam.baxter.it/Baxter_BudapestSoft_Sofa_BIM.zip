Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: 59b8111e-730f-4585-b731-42507ff347e0, VersionGUID: ebcc70c9-1572-425e-a227-b077f3921982, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Coordinate condivise]
File name: BUDAPEST SOFT_110 x 200 H76 Dormeuse Right Armrest.ifc
Time: 2026-02-24T09:21:50+01:00
Written by: ODA SDAI 25.12
Made in: Autodesk - Revit 26.4.0.32 (ITA) - 26.4.0.32

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 999999; RefLongitude: 12, 35, 59, 999999; RefElevation: 0 m

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 2

# IfcBuildingStorey (2)
Name | LongName | Elevation (m)
0 - Piano Terra | 0 - Piano Terra | 0
1 - Piano Primo | 1 - Piano Primo | 3.1

# IfcFurnishingElement: BUDAPEST SOFT_110 x 200 H76 Dormeuse Right Armrest:BUDAPEST SOFT_110 x 200 H76 Dormeuse Right Armrest, BUDAPEST SOFT_110 x 200 H76 Dormeuse Right Armrest:BUDAPEST SOFT_110 x 200 H76 Dormeuse Right Armrest:144598
In: 0 - Piano Terra
Type - Material: Kashmir Chantilly, Brushed Unfinished Metal
Type - Pset_ManufacturerTypeInformation - Manufacturer: Baxter S.r.l.
Pset_QuantityTakeOff - Reference: BUDAPEST SOFT_110 x 200 H76 Dormeuse Right Armrest
