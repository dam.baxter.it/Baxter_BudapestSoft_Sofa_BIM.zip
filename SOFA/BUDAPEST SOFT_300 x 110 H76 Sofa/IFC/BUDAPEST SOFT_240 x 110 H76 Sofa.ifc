Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: 1bd62e7d-8e6d-4a61-97b6-d9212a2d5a0e, VersionGUID: d1c86191-a285-4524-a33c-5859e233791e, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Coordinate condivise]
File name: BUDAPEST SOFT_240 x 110 H76 Sofa.ifc
Time: 2026-02-16T15:15:15+01:00
Written by: ODA SDAI 25.12
Made in: Autodesk - Revit 26.4.0.32 (ITA) - 26.4.0.32

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 999999; RefLongitude: 12, 35, 59, 999999; RefElevation: 0 m

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 2

# IfcBuildingStorey (2)
Name | LongName | Elevation (m)
0 - Piano Terra | 0 - Piano Terra | 0
1 - Piano Primo | 1 - Piano Primo | 3.1

# IfcFurnishingElement: BUDAPEST SOFT_300 x 110 H76 Sofa:BUDAPEST SOFT_300 x 110 H76, BUDAPEST SOFT_300 x 110 H76 Sofa:BUDAPEST SOFT_300 x 110 H76:148258
In: 0 - Piano Terra
Type - Material: Kashmir Chantilly, <Unnamed>, Brushed Unfinished Metal
Type - Pset_ManufacturerTypeInformation - Manufacturer: Baxter S.r.l.
Pset_QuantityTakeOff - Reference: BUDAPEST SOFT_300 x 110 H76
