Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: d531f8ee-b3c5-4d19-a8ec-9636aadd9e03, VersionGUID: e7fb63d6-88aa-4091-9725-700484e8a72a, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Coordinate condivise]
File name: BUDAPEST SOFT_95 x 140 H76 Central Module.ifc
Time: 2026-02-17T10:54:16+01:00
Written by: ODA SDAI 25.12
Made in: Autodesk - Revit 26.4.0.32 (ITA) - 26.4.0.32

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 999999; RefLongitude: 12, 35, 59, 999999; RefElevation: 0 m

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 2

# IfcBuildingStorey (2)
Name | LongName | Elevation (m)
0 - Piano Terra | 0 - Piano Terra | 0
1 - Piano Primo | 1 - Piano Primo | 3.1

# IfcFurnishingElement: BUDAPEST SOFT_95 x 140 H76 Central Module:BUDAPEST SOFT_95 x 140 H76 Right Armrest, BUDAPEST SOFT_95 x 140 H76 Central Module:BUDAPEST SOFT_95 x 140 H76 Right Armrest:147688
In: 0 - Piano Terra
Type - Material: Kashmir Chantilly, Brushed Unfinished Metal
Type - Pset_ManufacturerTypeInformation - Manufacturer: Baxter S.r.l.
Pset_QuantityTakeOff - Reference: BUDAPEST SOFT_95 x 140 H76 Right Armrest
